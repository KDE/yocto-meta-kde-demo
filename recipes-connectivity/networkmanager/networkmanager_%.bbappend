EXTRA_OECONF += " --with-netconfig=no"
