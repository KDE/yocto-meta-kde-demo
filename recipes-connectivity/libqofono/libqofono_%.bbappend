FILES_${PN} += " \
    ${libdir}/qml/MeeGo/QOfono/* \
"
