FILES:${PN} += " \
    ${libdir}/qml/MeeGo/QOfono/* \
"
