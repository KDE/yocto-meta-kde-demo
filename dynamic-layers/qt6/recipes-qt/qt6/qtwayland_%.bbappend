DEPENDS += " \
    virtual/egl \
"

