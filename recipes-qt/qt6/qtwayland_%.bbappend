DEPENDS += " \
    virtual/egl \
"

PACKAGECONFIG += " \
    dmabuf-client-buffer \
    dmabuf-server-buffer \
"
