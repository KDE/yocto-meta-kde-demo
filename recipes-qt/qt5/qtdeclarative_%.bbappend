PACKAGECONFIG:append = " \
    qml-debug \
"
