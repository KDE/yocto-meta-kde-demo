PACKAGECONFIG_append += " \
    hunspell \
    lang-all \
    lipi-toolkit \
"
